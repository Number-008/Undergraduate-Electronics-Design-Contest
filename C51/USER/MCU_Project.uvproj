# Keil uVision project MCU_Project.uvproj, settings and files
target MCU_Project (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: MCU_Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Source\DELAY;..\Source\KEY;..\Source\LCD;..\Source\AD9851;..\Source\ADS7818
  group Start
    ./: STARTUP.A51
  group USER
    ./: main.c 珞珈第三版51地址映射.txt
  group Source
    ../Source/DELAY/: delay.c
    ../Source/KEY/: key.c
    ../Source/LCD/: lcd.c
    ../Source/AD9851/: ad9851.c
    ../Source/ADS7818/: ads7818.c
